# Keil uVision project gd32h759temple.uvprojx, settings and files
target gh32h759temple (6230000::V6.23::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gh32h759temple +hex
  c flags: OneElfS=1 v6Lang=6 v6LangP=9 wLevel=3
  c misc: -Wno-invalid-source-encoding -fno-finite-math-only
  c include: ..\Firmware\CMSIS\GD\GD32H7xx\Include;..\Firmware\GD32H7xx_standard_peripheral\Include;..\freeRtos\kernel\include;..\freeRtos\kernel\portable\GCC\ARM_CM7\r0p1;..\User;..\Lib;..\Lib\ring_buffer;..\Lib\logging;..\Lib\cli;..\Driver;..\Lib\lwip_2_2_1\contrib\ports\GD32H7xx\arch;..\Lib\lwip_2_2_1\contrib\ports\GD32H7xx\FreeRTOS;..\Lib\lwip_2_2_1\src\include\lwip;..\Lib\lwip_2_2_1\src\include\netif;..\Lib\lwip_2_2_1\src\include\lwip\prot;..\Lib\lwip_2_2_1\src\include;..\Lib\lwip_2_2_1\contrib\ports\GD32H7xx;..\App\config;..\App\tcp;..\Driver\net;..\Driver\phy;..\App;..\App\ota
  library: MicroLIB
  memory RVCT4: ROM 0x8020200 size 0x9fe00
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group App
    ../App/: gd32h7xx_it.c main.c
  group App/tcp
    ../App/tcp/: tcp_client.c ota_server.c
  group App/ota
    ../App/ota/: ota_flash.c
  group Driver
    ../Driver/usart/: console_usart.c
    ../Driver/can/: module_can.c
    ../Driver/net/: netconf.c
    ../Driver/phy/: bsp_lan8720a_rtos.c
  group Lib
    ../Lib/cli/: FreeRTOS_CLI.c cli.c
  group Peripherals
    ../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group FreeRtos
    ../freeRtos/kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freeRtos/kernel/portable/GCC/ARM_CM7/r0p1/: port.c
    ../freeRtos/kernel/portable/MemMang/: heap_4.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Startup
    ../Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group lwip_port
    ../Lib/lwip_2_2_1/contrib/ports/GD32H7xx/FreeRTOS/: ethernetif.c sys_arch.c
  group lwip
    ../Lib/lwip_2_2_1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Lib/lwip_2_2_1/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Lib/lwip_2_2_1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Lib/lwip_2_2_1/src/netif/: ethernet.c
